# Keil uVision project FinalProject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: FinalProject
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f2xx.s TextMessageMain.c
    ./boardlibs/: RTX_Conf_CM.c GLCD_16bitIF_STM32F2xx.c I2C_STM32F2xx.c JOY.c KBD.c LED.c Serial.c sram.c system_stm32f2xx.c TSC_STMPE811.c
    ./userlibs/: LinkedList.c
